# Keil uVision project Project.uvprojx, settings and files
target STM32F3-Discovery_Demo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F3-Discovery_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32F3_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F3-Discovery;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group Libraries/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pcd.c stm32f3xx_hal_spi.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_ll_usb.c
  group Appli/User
    ../Src/: usbd_desc.c main.c stm32f3xx_it.c usbd_conf.c
  group Libraries/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303xc.s
    ../Src/: system_stm32f3xx.c
  group Doc
    ../: readme.txt
  group Libraries/Components
    ../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
  group Appli/Test
    ../Src/: selftest.c
  group Middlewares/STM32_USBD_Library/Class
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Libraries/STM32F3-Discovery
    ../../../../Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery_accelerometer.c stm32f3_discovery.c stm32f3_discovery_gyroscope.c
software components: CMSIS:CORE 4.1.0
