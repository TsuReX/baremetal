# IAR project STM32F3-Discovery_Demo.ewp, settings and files
configuration STM32F3-Discovery_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xC; USE_HAL_DRIVER; USE_STM32F3_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32F3-Discovery; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F3-DISCOVERY_Demo.hex
  ILINK.IlinkOutputFile: STM32F3-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appli/Test
    ../Src/: selftest.c
  group Appli/User
    ../Src/: main.c stm32f3xx_it.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Libraries/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xc.s
    ../Src/: system_stm32f3xx.c
  group Libraries/Components
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
  group Libraries/STM32F3-Discovery
    ../../../../Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c stm32f3_discovery_accelerometer.c stm32f3_discovery_gyroscope.c
  group Libraries/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
