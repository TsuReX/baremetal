# Keil uVision project Project.uvprojx, settings and files
target STM32373C_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F373VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x803FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32373C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F373xC,USE_HAL_DRIVER,USE_STM32373C_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32373C_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32373C_EVAL
    ../../../../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval_lcd.c stm32373c_eval.c
  group Application/User
    ../Src/: stm32f3xx_it.c tsl_user.c stmCriticalSection.c stm32f3xx_hal_msp.c main.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f373xc.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9328/: ili9328.c
    ../../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_globals.c tsl_ecs.c tsl_touchkey.c tsl_time.c tsl_acq.c tsl_object.c tsl_dxs.c tsl_acq_tsc.c tsl_filter.c tsl.c tsl_linrot.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal.c stm32f3xx_hal_dma.c stm32f3xx_hal_tsc.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_cortex.c stm32f3xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
