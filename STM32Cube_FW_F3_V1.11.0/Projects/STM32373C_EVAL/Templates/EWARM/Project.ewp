# IAR project Project.ewp, settings and files
configuration STM32373C_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373xC ST STM32F373xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F373xC; USE_HAL_DRIVER; USE_STM32373C_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32373C_EVAL; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Utilities\Log; ..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32373C_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f373xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32373C_EVAL
    ../../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_exti.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32f373xc.s
  group Example/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
