# Keil uVision project Project.uvprojx, settings and files
target STM32373C_EVAL (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x803FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32373C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F373xC,USE_HAL_DRIVER,USE_STM32373C_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32373C_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f373xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/User
    ../Src/: audio_sample.c stm32f3xx_hal_msp.c main.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../../Drivers/BSP/Components/ili9328/: ili9328.c
    ../../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c
  group Drivers/BSP/STM32373C_EVAL
    ../../../../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval_audio.c stm32373c_eval.c stm32373c_eval_lcd.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_cortex.c stm32f3xx_hal.c stm32f3xx_hal_i2s.c stm32f3xx_hal_dma.c stm32f3xx_hal_rcc.c
software components: CMSIS:CORE 4.1.0
