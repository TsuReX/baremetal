# Keil uVision project Project.uvprojx, settings and files
target STM32303E_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08004000-0x807FFFF) IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE,USE_STM32303E_EVAL
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32303E_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: main.c stm32f3xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32303E_EVAL
    ../../../../../../Drivers/BSP/STM32303E_EVAL/: stm32303e_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
