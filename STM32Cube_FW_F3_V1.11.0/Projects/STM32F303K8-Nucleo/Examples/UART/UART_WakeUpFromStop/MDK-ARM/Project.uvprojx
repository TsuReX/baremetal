# Keil uVision project Project.uvprojx, settings and files
target STM32F303K8_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303K8_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F303x8,USE_STM32F3XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F3xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/User
    ../Src/: stm32f3xx_hal_msp.c main.c stm32f3xx_it.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_flash_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr.c stm32f3xx_hal_uart.c stm32f3xx_hal_flash.c
  group Drivers/BSP/STM32F3xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32F3xx_Nucleo_32/: stm32f3xx_nucleo_32.c
  group Example/MDK-ARM
    ./: startup_stm32f303x8.s
software components: CMSIS:CORE 4.1.0
